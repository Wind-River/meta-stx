FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0900-inject-milisec-in-syslog-date.patch \
	"
