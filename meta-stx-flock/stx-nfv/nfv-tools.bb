
require nfv-common.inc

S = "${S_DIR}/nfv/nfv-tools"

inherit setuptools
