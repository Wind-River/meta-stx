
inherit setuptools

require fault-common.inc

S = "${S_DIR}/python-fmclient/fmclient"
