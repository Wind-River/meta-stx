inherit setuptools

require fault-common.inc

S="${S_DIR}/fm-api"
