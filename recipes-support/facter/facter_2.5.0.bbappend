FILESEXTRAPATHS_append := ":${THISDIR}/files:"

SRC_URI += " file://add_poky_lsbdistid.diff"
