#
#extract and update etc with contents from python-pycadf-common rpm file
