RDEPENDS_${PN}_append = " \
	${PYTHON_PN}-pygments \
	${PYTHON_PN}-typing \
	"

# TODO:
# Need these modules
#${PYTHON_PN}-alabaster
#${PYTHON_PN}-imagesize
#${PYTHON_PN}-packaging
#${PYTHON_PN}-snowballstemmer
#${PYTHON_PN}-sphinxcontrib-websupport
