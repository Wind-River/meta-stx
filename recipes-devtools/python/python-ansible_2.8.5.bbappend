ANSIBLE_WHITELIST_MODULES = "  \
	cloud \
	clustering \
	commands \
	database \
	files \
	identity \
	inventory \
	messaging \
	monitoring \
	net_tools \
	network \
	notification \
	packaging \
	remote_management \
	source_control \
	storage \
	system \
	utilities \
	web_infrastructure \
	"
