DESCRIPTION = "term.js javascript library packaged for setuptools (easy_install) / pip."

HOMEPAGE = "https://github.com/chjj/term.js"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=ed5e81877e166767972cb01498949771"

PV = "0.0.7.0"
inherit pypi

PYPI_PACKAGE = "XStatic-term.js"

SRC_URI[md5sum] = "7434ecf6f5680c293cf3806245dc946b"
SRC_URI[sha256sum] = "b5f3ab69cb638391f04254913a11b2aab08e2d51c5b81bb6a564c5a6d442bd31"
