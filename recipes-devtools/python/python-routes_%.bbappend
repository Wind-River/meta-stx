RDEPENDS_python-routes_remove = "${PYTHON_PN}-repoze-lru"
RDEPENDS_python-routes_append = "${PYTHON_PN}-repoze.lru"
