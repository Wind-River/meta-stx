DESCRIPTION = "The Python perf module is a toolkit to write, run and analyze benchmarks."
LICENSE = "Apache-2.0"
LIC_FILES_CHKSUM = "file://COPYING;md5=78bc2e6e87c8c61272937b879e6dc2f8"

SRC_URI[sha256sum] = "f7fd3a9a174a17ca36de63563f394eaafc7d4ce11fd3ae7c28d4c38cf6403bef"

PYPI_PACKAGE = "perf"
inherit pypi setuptools
