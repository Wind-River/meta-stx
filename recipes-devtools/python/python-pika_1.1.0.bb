DESCRIPTION = "Pika is a pure-Python implementation of the AMQP 0-9-1 protocol including RabbitMQ’s extensions."
LICENSE = "BSD"
LIC_FILES_CHKSUM = "file://LICENSE;md5=535836bf0a5de515a7bfee026075701d"

SRC_URI[sha256sum] = "9fa76ba4b65034b878b2b8de90ff8660a59d925b087c5bb88f8fdbb4b64a1dbf"


PYPI_PACKAGE = "pika"
inherit pypi setuptools
