DEPENDS += "\
	python-pbr-native \
	"
